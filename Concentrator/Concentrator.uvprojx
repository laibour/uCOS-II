# Keil uVision project Concentrator.uvprojx, settings and files
target Concentrator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: J01-01-20-V1_9 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/@L.bin ./Output/@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\User;.\Drivers;.\Drivers\debug;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Drivers\radio;.\Drivers\net;.\Drivers\memory;.\uCOS-II\Ports;.\uCOS-II\Source;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c sys_config.c
  group App
    ./App/: app.h app_cfg.h os_cfg.h includes.h
  group Debug
    ./Drivers/debug/: debug.c
  group uCOS-II\Port
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II\Src
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c
software components: CMSIS:CORE 4.3.0
